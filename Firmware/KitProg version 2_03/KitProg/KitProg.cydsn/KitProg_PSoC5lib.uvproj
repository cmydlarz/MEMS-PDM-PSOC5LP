# Keil uVision project KitProg_PSoC5lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C5666LTI-LP005 Cypress
  cpu: "IRAM(0x1FFFE000-0x20001FFF)IROM(0x4D00-0xFFBF)CLOCK(67000000)CPUTYPE( "Cortex-M3") ESEL ELITTLE"
  output: KitProg_PSoC5lib (library)
  group Source Files
    ./Generated_Source/PSoC5/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicegnu.inc cydevicerv.inc cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h cm3gcc.ld Cm3RealView.scat core_cm3_psoc5.h core_cm3.c core_cm3.h CyBootAsmGnu.s CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c project.h Clock_I2C.c Clock_I2C.h SWDCLK_aliases.h SWDCLK.c SWDCLK.h SWDIO_aliases.h SWDIO.c SWDIO.h Pin_StatusLED_aliases.h Pin_StatusLED.c Pin_StatusLED.h ADC_Voltage_Target.c ADC_Voltage_Target.h ADC_Voltage_Target_PM.c ADC_Voltage_Target_INT.c ADC_Voltage_Target_theACLK.c ADC_Voltage_Target_theACLK.h ADC_Voltage_Target_Ext_CP_Clk.c ADC_Voltage_Target_Ext_CP_Clk.h ADC_Voltage_Target_AMux.c ADC_Voltage_Target_AMux.h AMux.c AMux.h Clock_UART.c Clock_UART.h I2CHW.c I2CHW.h I2CHW_BOOT.c I2CHW_INT.c I2CHW_PM.c I2CHW_SLAVE.c I2CHW_MASTER.c I2CHW_PVT.h Pin_VTarget_aliases.h Pin_VTarget.c Pin_VTarget.h Pin_I2C_SCL_aliases.h Pin_I2C_SCL.c Pin_I2C_SCL.h Pin_I2C_SDA_aliases.h Pin_I2C_SDA.c Pin_I2C_SDA.h Pin_UART_Tx_aliases.h Pin_UART_Tx.c Pin_UART_Tx.h Pin_UART_Rx_aliases.h Pin_UART_Rx.c Pin_UART_Rx.h SWDXRES_aliases.h SWDXRES.c SWDXRES.h USBFS.c USBFS.h USBFS_audio.c USBFS_audio.h USBFS_boot.c USBFS_cdc.c USBFS_cdc.h USBFS_cls.c USBFS_descr.c USBFS_drv.c USBFS_episr.c USBFS_hid.c USBFS_hid.h USBFS_pm.c USBFS_std.c USBFS_vnd.c USBFS_cdc.inf USBFS_midi.c USBFS_midi.h USBFS_Dm_aliases.h USBFS_Dm.c USBFS_Dm.h USBFS_VBUS_aliases.h USBFS_VBUS.c USBFS_VBUS.h USBFS_Dp_aliases.h USBFS_Dp.c USBFS_Dp.h Bootloadable.c Bootloadable.h UART_Bridge.c UART_Bridge.h UART_Bridge_PM.c UART_Bridge_INT.c UART_Bridge_BOOT.c Pin_SDAPullUp_Enable_aliases.h Pin_SDAPullUp_Enable.c Pin_SDAPullUp_Enable.h Pin_SCLPullUp_Enable_aliases.h Pin_SCLPullUp_Enable.c Pin_SCLPullUp_Enable.h Pin_HWVersionA_aliases.h Pin_HWVersionA.c Pin_HWVersionA.h Pin_HWVersionB_aliases.h Pin_HWVersionB.c Pin_HWVersionB.h Pin_HWVersionC_aliases.h Pin_HWVersionC.c Pin_HWVersionC.h Pin_HWVersionD_aliases.h Pin_HWVersionD.c Pin_HWVersionD.h Pin_HWVersionE_aliases.h Pin_HWVersionE.c Pin_HWVersionE.h Pin_HWVersionF_aliases.h Pin_HWVersionF.c Pin_HWVersionF.h isr_UsbSuspend.c isr_UsbSuspend.h Clock_UsbSuspend.c Clock_UsbSuspend.h Timer_UsbSuspend.c Timer_UsbSuspend.h Timer_UsbSuspend_PM.c
target Release (ARM-GNU)
  device: CY8C5666LTI-LP005 Cypress
  cpu: as above
  output: KitProg_PSoC5lib (library)
